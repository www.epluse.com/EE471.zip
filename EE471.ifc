Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: Mon Aug 10 16:00:54 2020
Author: at3107
Written by: PTC Creo 1.0
Made in: PTC

# IfcProject, Default Project
LongName: Project Status; Phase: Project Status

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Part, EE471
In: Default Storey
PTC_Identity Data - DEVICENAME: Temperature Sensor with Remote Probe; ENCLOSUREDIMENSIONS: WxHxD = 80.8x55.3x39.5 mm (3.2x2.2x1.6"); ENCLOSUREMATERIAL: Polycarbonate / US approval UL94V-0 / IP65 / NEMA 4; MEASURAND1: Temperature; Measuring range -30…+105 °C (-22...+221 °F); OUTPUT1: Analogue voltage / current; 0-10 V / 4-20 mA; SUPPLY: 15-35 V DC or 24 V AC ±20%; OUTPUT2: Digital interface; RS485 with Modbus RTU or BACnet MS/TP; OUTPUT3: Passive T-Sensor; VOLUME: 168989; SURFACE_AREA: 22346.2; MASS: 168989; DENSITY: 1; CENTRE_OF_GRAVITY_X: 3.7645; CENTRE_OF_GRAVITY_Y: -2.1057; CENTRE_OF_GRAVITY_Z: 0.4898
